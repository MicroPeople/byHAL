<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Nucleo-L496ZG_Test.ewp</path>
  </project>
  <batchBuild />
</workspace>
