<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Gokit_WS2812B_Test.ewp</path>
  </project>
  <batchBuild />
</workspace>
